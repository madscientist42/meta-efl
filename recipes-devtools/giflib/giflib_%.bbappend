# Just add nativesdk support to help with tools that need this...
BBCLASSEXTEND += " nativesdk"
