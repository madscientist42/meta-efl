# Extend out the class spec so it's available for native/nativesdk
BBCLASSEXTEND = "native nativesdk"