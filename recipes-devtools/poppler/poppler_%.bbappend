# Add native/nativesdk support here...
BBCLASSEXTEND += "native nativesdk"
