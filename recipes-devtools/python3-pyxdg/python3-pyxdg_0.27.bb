DESCRIPTION = "Variables defined by the XDG Base Directory Specification"
LICENSE = "LGPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=f30a9716ef3762e3467a2f62bf790f0a"

inherit pypi setuptools3

PYPI_PACKAGE = "pyxdg"

SRC_URI[sha256sum] = "80bd93aae5ed82435f20462ea0208fb198d8eec262e831ee06ce9ddb6b91c5a5"

